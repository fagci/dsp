// BCH codes of DVB-S2 / DVB-T2 (EN 302 307 table 6a-6c, EN 302 755 table 6): t-error correcting, shortened,
// normal frames over GF(2^16), short frames over GF(2^14). Bits are 0/1 bytes, first transmitted bit first.
#pragma once
#include "common.h"

namespace dvbofdm {

struct Bch {
  int m = 0, t = 0, kbch = 0, n = 0, par = 0;
  std::vector<uint16_t> exp_, log_;
  std::vector<uint8_t> gen;  // generator polynomial, gen[i] = coefficient of x^i, degree par
  std::vector<uint64_t> tab; // [256][3] remainder contribution of the top byte of the register

  // Polynomials g1..g12 from the standard, coefficients low degree first
  static const int *poly(bool shortFrame, int i) {
    static const int N[12][17] = {
      {1,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,1}, {1,1,0,0,1,1,1,0,1,0,0,0,0,0,0,0,1}, {1,0,1,1,1,1,0,1,1,1,1,1,0,0,0,0,1},
      {1,0,1,0,1,0,1,0,0,1,0,1,1,0,1,0,1}, {1,1,1,1,0,1,0,0,1,1,1,1,1,0,0,0,1}, {1,0,1,0,1,1,0,1,1,1,1,0,1,1,1,1,1},
      {1,0,1,0,0,1,1,0,1,1,1,1,0,1,0,1,1}, {1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,0,1}, {1,0,0,0,0,1,0,1,0,1,1,1,0,0,0,0,1},
      {1,1,1,0,0,1,0,1,1,0,1,0,1,1,1,0,1}, {1,0,1,1,0,1,0,0,0,1,0,1,1,1,0,0,1}, {1,1,0,0,0,1,1,1,0,1,0,1,1,0,0,0,1}};
    static const int S[12][15] = {
      {1,1,0,1,0,1,0,0,0,0,0,0,0,0,1}, {1,0,0,0,0,0,1,0,1,0,0,1,0,0,1}, {1,1,1,0,0,0,1,0,0,1,1,0,0,0,1},
      {1,0,0,0,1,0,0,1,1,0,1,0,1,0,1}, {1,0,1,0,1,0,1,0,1,1,0,1,0,1,1}, {1,0,0,1,0,0,0,1,1,1,0,0,0,1,1},
      {1,0,1,0,0,1,1,1,0,0,1,1,0,1,1}, {1,0,0,0,0,1,0,0,1,1,1,1,0,0,1}, {1,1,1,1,0,0,0,0,0,1,1,0,0,0,1},
      {1,0,0,1,0,0,1,0,0,1,0,1,1,0,1}, {1,0,0,0,1,0,0,0,0,0,0,1,1,0,1}, {1,1,1,1,0,1,1,1,1,0,1,0,0,1,1}};
    return shortFrame ? S[i] : N[i];
  }

  void init(bool shortFrame, int t_, int kbch_) {
    t = t_; kbch = kbch_;
    m = shortFrame ? 14 : 16; par = m * t; n = kbch + par;
    // field generated by g1
    const int *g1 = poly(shortFrame, 0);
    int poly1 = 0; for (int i = 0; i <= m; i++) if (g1[i]) poly1 |= 1 << i;
    int size = 1 << m;
    exp_.assign(2 * size, 0); log_.assign(size, 0);
    int x = 1;
    for (int i = 0; i < size - 1; i++) { exp_[i] = (uint16_t)x; log_[x] = (uint16_t)i; x <<= 1; if (x & size) x ^= poly1; }
    for (int i = size - 1; i < 2 * size; i++) exp_[i] = exp_[i - (size - 1)];
    // generator = product of the first t polynomials
    std::vector<uint8_t> g(1, 1);
    for (int k = 0; k < t; k++) {
      const int *p = poly(shortFrame, k);
      std::vector<uint8_t> r(g.size() + m, 0);
      for (size_t i = 0; i < g.size(); i++) if (g[i]) for (int j = 0; j <= m; j++) if (p[j]) r[i + j] ^= 1;
      g = r;
    }
    gen = g;  // size par+1
    tab.assign(256 * 3, 0);
    for (int v = 0; v < 256; v++) {
      std::vector<uint8_t> r(par + 8, 0);
      for (int i = 0; i < 8; i++) r[par + i] = (v >> i) & 1;           // byte v shifted up to x^par .. x^(par+7)
      for (int d = par + 7; d >= par; d--) if (r[d]) for (int j = 0; j <= par; j++) r[d - par + j] ^= gen[j];
      for (int i = 0; i < par; i++) if (r[i]) tab[v * 3 + (i >> 6)] |= 1ull << (i & 63);
    }
  }

  // Remainder of c(x) mod g(x) over the first n bits; zero when no error was found
  bool clean(const uint8_t *bits) const {
    uint64_t R[3] = {0, 0, 0};            // bit i of R = coefficient of x^i of the running remainder
    int nb = n / 8;
    for (int k = 0; k < nb; k++) {
      int byte = 0; for (int j = 0; j < 8; j++) byte = (byte << 1) | bits[k * 8 + j];
      // top byte of the register = bits par-8 .. par-1; the first transmitted bit is the highest power
      int top = 0;
      for (int j = 0; j < 8; j++) { int p = par - 1 - j; top = (top << 1) | (int)((R[p >> 6] >> (p & 63)) & 1); }
      int idx = (top ^ byte) & 255;
      // shift register left by 8
      R[2] = (R[2] << 8) | (R[1] >> 56); R[1] = (R[1] << 8) | (R[0] >> 56); R[0] <<= 8;
      if (par < 192) R[2] &= (1ull << (par - 128)) - 1;
      for (int w = 0; w < 3; w++) R[w] ^= tab[idx * 3 + w];
    }
    return !(R[0] | R[1] | R[2]);
  }

  // Corrects up to t errors in place. Returns number of corrections, or -1 when uncorrectable.
  int decode(uint8_t *bits) const {
    if (clean(bits)) return 0;
    int size1 = (1 << m) - 1;
    auto mul = [&](int a, int b) { return (a && b) ? exp_[log_[a] + log_[b]] : 0; };
    auto inv = [&](int a) { return exp_[size1 - log_[a]]; };
    // syndromes S1..S2t : S_j = sum_i b_i alpha^(j*(n-1-i))
    std::vector<int> S(2 * t + 1, 0);
    for (int i = 0; i < n; i++) if (bits[i]) {
      int e = n - 1 - i;
      for (int j = 1; j <= 2 * t; j++) S[j] ^= exp_[(int)(((int64_t)j * e) % size1)];
    }
    bool any = false; for (int j = 1; j <= 2 * t; j++) if (S[j]) any = true;
    if (!any) return 0;
    // Berlekamp-Massey
    std::vector<int> C(2 * t + 2, 0), B(2 * t + 2, 0), T;
    C[0] = B[0] = 1;
    int L = 0, mm = 1, b = 1;
    for (int nn = 0; nn < 2 * t; nn++) {
      int d = S[nn + 1];
      for (int i = 1; i <= L; i++) d ^= mul(C[i], S[nn + 1 - i]);
      if (!d) { mm++; continue; }
      T = C;
      int coef = mul(d, inv(b));
      for (int i = 0; i + mm < (int)C.size(); i++) if (B[i]) C[i + mm] ^= mul(coef, B[i]);
      if (2 * L <= nn) { L = nn + 1 - L; B = T; b = d; mm = 1; } else mm++;
    }
    if (L > t) return -1;
    // Chien search over the n code positions
    std::vector<int> pos;
    for (int e = 0; e < n; e++) {
      // root test: C(alpha^-e) == 0
      int v = 0;
      for (int i = 0; i <= L; i++) if (C[i]) v ^= exp_[(int)((log_[C[i]] + (int64_t)i * ((size1 - e) % size1)) % size1)];
      if (!v) pos.push_back(e);
    }
    if ((int)pos.size() != L) return -1;
    for (int e : pos) bits[n - 1 - e] ^= 1;
    return L;
  }
};

}  // namespace dvbofdm
